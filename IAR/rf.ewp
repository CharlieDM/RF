# IAR project rf.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m168 ATmega168
  ICCAVR.newCCIncludePaths: ..\app; ..\pub; ..\driver; ..\interface
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 1
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm168.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group app
    ../app/: data.h main.c
  group driver
    ../driver/: hal_io.c hal_io.h hal_timer.c hal_timer.h
  group interface
    ../interface/: interface.c interface.h rf_send.c rf_send.h
  group pub
    ../pub/: includes.h type_def.h
